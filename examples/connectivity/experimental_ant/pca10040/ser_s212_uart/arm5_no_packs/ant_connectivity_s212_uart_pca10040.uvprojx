# Keil uVision project ant_connectivity_s212_uart_pca10040.uvprojx, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: ANT_STACK_SUPPORT_REQD APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 S212 SER_CONNECTIVITY SOFTDEVICE_PRESENT __HEAP_SIZE=1024 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\timer\experimental;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\serialization\common;..\..\..\..\..\..\components\serialization\common\struct_ser\ant;..\..\..\..\..\..\components\serialization\common\struct_ser\ble;..\..\..\..\..\..\components\serialization\common\transport;..\..\..\..\..\..\components\serialization\common\transport\ser_phy;..\..\..\..\..\..\components\serialization\common\transport\ser_phy\config;..\..\..\..\..\..\components\serialization\connectivity;..\..\..\..\..\..\components\serialization\connectivity\codecs\ant\middleware;..\..\..\..\..\..\components\serialization\connectivity\codecs\ant\serializers;..\..\..\..\..\..\components\serialization\connectivity\codecs\ble\serializers;..\..\..\..\..\..\components\serialization\connectivity\codecs\common;..\..\..\..\..\..\components\serialization\connectivity\hal;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s212\headers;..\..\..\..\..\..\components\softdevice\s212\headers\nrf52;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DANT_STACK_SUPPORT_REQD,-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10040,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DS212,-DSER_CONNECTIVITY,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=1024,-D__STACK_SIZE=2048
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x12000 size 0x6e000
  memory RVCT9: RAM 0x20006b80 size 0x9480
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_BLE
    ../../../../../../components/ble/ble_dtm/: ble_dtm.c ble_dtm_hw_nrf52.c
  group nRF_Drivers
    ../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/experimental/: app_timer2.c drv_rtc.c
    ../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_Serialization
    ../../../../../../components/serialization/connectivity/codecs/ant/serializers/: ant_acknowledge_message_tx.c ant_active_search_sharing_cycles_get.c ant_active_search_sharing_cycles_set.c ant_adv_burst_config_set.c ant_broadcast_message_tx.c ant_capabilities_get.c ant_channel_assign.c ant_channel_close.c ant_channel_id_get.c ant_channel_id_set.c ant_channel_low_priority_rx_search_timout_set.c ant_channel_open_with_offset.c ant_channel_period_get.c ant_channel_period_set.c ant_channel_radio_freq_get.c ant_channel_radio_freq_set.c ant_channel_radio_tx_power_set.c ant_channel_rx_search_timeout_set.c ant_channel_status_get.c ant_channel_unassign.c ant_coex_config_get.c ant_coex_config_set.c ant_crypto_channel_enable.c ant_crypto_info_get.c ant_crypto_info_set.c ant_crypto_key_set.c ant_cw_test_mode.c ant_cw_test_mode_init.c ant_enable.c ant_event.c ant_event_rx.c ant_id_list_add.c ant_id_list_config.c ant_lib_config_clear.c ant_lib_config_get.c ant_lib_config_set.c ant_network_address_set.c ant_prox_search_set.c ant_rx_scan_mode_start.c ant_search_channel_priority_set.c ant_search_waveform_set.c ant_stack_reset.c ant_version_get.c
    ../../../../../../components/serialization/common/struct_ser/ant/: ant_struct_serialization.c
    ../../../../../../components/serialization/connectivity/codecs/common/: ble_dtm_init.c conn_mw.c conn_mw_nrf_soc.c
    ../../../../../../components/serialization/common/: ble_serialization.c cond_field_serialization.c ser_dbg_sd_str.c
    ../../../../../../components/serialization/connectivity/codecs/ant/middleware/: conn_mw_ant.c
    ../../../../../../components/serialization/connectivity/hal/: dtm_uart.c
    ../../../../../../components/serialization/connectivity/codecs/ble/serializers/: nrf_soc_conn.c
    ../../../../../../components/serialization/common/struct_ser/ble/: nrf_soc_struct_serialization.c
    ../../../../../../components/serialization/connectivity/: ser_conn_cmd_decoder.c ser_conn_dtm_cmd_decoder.c ser_conn_error_handling.c ser_conn_event_encoder.c ser_conn_handlers.c ser_conn_pkt_decoder.c ser_conn_reset_cmd_decoder.c
    ../../../../../../components/serialization/common/transport/: ser_hal_transport.c
    ../../../../../../components/serialization/common/transport/ser_phy/: ser_phy_uart.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ant.c nrf_sdh_soc.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.24.1
