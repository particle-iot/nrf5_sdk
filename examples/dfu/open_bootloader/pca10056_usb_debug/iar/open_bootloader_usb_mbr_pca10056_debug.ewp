# IAR project open_bootloader_usb_mbr_pca10056_debug.ewp, settings and files
configuration nrf52840_xxaa_debug (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; DEBUG_NRF; FLOAT_ABI_HARD; MBR_PRESENT; NRF52840_XXAA; NRF_DFU_DEBUG_VERSION; NRF_DFU_SETTINGS_VERSION=2; SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\components\boards; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\components\libraries\bootloader; ..\..\..\..\..\components\libraries\bootloader\dfu; ..\..\..\..\..\components\libraries\bootloader\serial_dfu; ..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\components\libraries\crypto\backend\cc310; ..\..\..\..\..\components\libraries\crypto\backend\cc310_bl; ..\..\..\..\..\components\libraries\crypto\backend\cifra; ..\..\..\..\..\components\libraries\crypto\backend\mbedtls; ..\..\..\..\..\components\libraries\crypto\backend\micro_ecc; ..\..\..\..\..\components\libraries\crypto\backend\nrf_hw; ..\..\..\..\..\components\libraries\crypto\backend\nrf_sw; ..\..\..\..\..\components\libraries\crypto\backend\oberon; ..\..\..\..\..\components\libraries\crypto\backend\optiga; ..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\components\libraries\led_softblink; ..\..\..\..\..\components\libraries\log; ..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\components\libraries\low_power_pwm; ..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\components\libraries\slip; ..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\components\libraries\stack_info; ..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\components\libraries\timer\experimental; ..\..\..\..\..\components\libraries\usbd; ..\..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\softdevice\mbr\nrf52840\headers; ..\..\..\..\..\components\toolchain\cmsis\include; ..\..; ..\..\..\..\..\external\fprintf; ..\..\..\..\..\external\nano-pb; ..\..\..\..\..\external\nrf_cc310\include; ..\..\..\..\..\external\nrf_cc310_bl\include; ..\..\..\..\..\external\nrf_oberon; ..\..\..\..\..\external\nrf_oberon\include; ..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\external\utf_converter; ..\..\..\..\..\integration\nrfx; ..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\modules\nrfx; ..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: open_bootloader_usb_mbr_pca10056_debug.hex
  ILINK.IlinkOutputFile: open_bootloader_usb_mbr_pca10056_debug.out
  ILINK.IlinkIcfFile: open_bootloader_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_USB_DFU
    ../../../../../components/libraries/bootloader/serial_dfu/: nrf_dfu_serial_usb.c
  group nRF_Log
    ../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../components/boards/: boards.c
  group nano-pb
    ../../../../../external/nano-pb/: pb_common.c pb_decode.c
  group nRF_Crypto backend CC310_BL
    ../../../../../components/libraries/crypto/backend/cc310_bl/: cc310_bl_backend_ecc.c cc310_bl_backend_ecdsa.c cc310_bl_backend_hash.c cc310_bl_backend_init.c cc310_bl_backend_shared.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../components/libraries/timer/experimental/: app_timer2.c drv_rtc.c
    ../../../../../components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ../../../../../components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ../../../../../components/libraries/crc32/: crc32.c
    ../../../../../components/libraries/led_softblink/: led_softblink.c
    ../../../../../components/libraries/low_power_pwm/: low_power_pwm.c
    ../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../components/libraries/slip/: slip.c
  group nRF_Drivers
    ../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_uart.c
    ../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_power.c nrfx_systick.c nrfx_uart.c nrfx_uarte.c nrfx_usbd.c
    ../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Oberon_Crypto
    ../../../../../external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: liboberon_2.0.7.a
  group nRF_Crypto
    ../../../../../components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group Application
    ../../../: dfu_public_key.c
    ../../: main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group nRF_Bootloader
    ../../../../../components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_final.c nrf_bootloader_dfu_timers.c nrf_bootloader_fw_activation.c nrf_bootloader_info.c nrf_bootloader_wdt.c
  group None
    ../../../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
  group nRF_DFU
    ../../../../../components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
  group nRF_Serial_DFU
    ../../../../../components/libraries/bootloader/serial_dfu/: nrf_dfu_serial.c
  group UTF8/UTF16 converter
    ../../../../../external/utf_converter/: utf.c
  group nrf_cc310_bl
    ../../../../../external/nrf_cc310_bl/lib/cortex-m4/hard-float/short-wchar/: libnrf_cc310_bl_0.9.12.a
  group nRF_Crypto backend Oberon
    ../../../../../components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
